<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>51.0E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>audio_rate*40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_3_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>11000</value></param>
<param><key>amp</key><value>1.8 if lsb_on else 0</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_3_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>120000</value></param>
<param><key>amp</key><value>1.0 / 7</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>decim</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>q_offset</value></param>
<param><key>label</key><value>DC offset Q</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-0.1</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,0,1,7</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>i_offset</value></param>
<param><key>label</key><value>DC offset I</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-0.1</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,7</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>lsb_on</value></param>
<param><key>label</key><value>LSB</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,3,1,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>usb_on</value></param>
<param><key>label</key><value>USB</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,4,1,1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>am_on</value></param>
<param><key>label</key><value>AM</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,2,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>Phase correction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-0.1</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,7</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>magnitude</value></param>
<param><key>label</key><value>Magnitude correction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-0.1</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,7</value></param>
</block>
<block>
<key>iqbalance_fix_cc</key>
<param><key>id</key><value>iqbalance_fix_cc_0</value></param>
<param><key>mag</key><value>magnitude</value></param>
<param><key>phase</key><value>phase</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>i_offset + 1j * q_offset</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>ant0</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mic_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>low_cutoff_freq</key><value>-2800</value></param>
<param><key>high_cutoff_freq</key><value>-200</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>mic_gain</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/ubuntu/Desktop/GRC Converted Files/Multi/KN0CK_Test_Wave_2.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_3_0</source_block_id><sink_block_id>blocks_multiply_xx_3_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_xx_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_4</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_3_0</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iqbalance_fix_cc_0</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_4</source_block_id><sink_block_id>iqbalance_fix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
